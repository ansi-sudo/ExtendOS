SUMMARY = "ExtendOS prod image"
DESCRIPTION = "ext4 ro rootfs running the ExtendOS app."
LICENSE = "MIT"

require extendos-image-base.inc

IMAGE_OVERHEAD_FACTOR = "1.0"
IMAGE_ROOTFS_EXTRA_SPACE = "4096"
