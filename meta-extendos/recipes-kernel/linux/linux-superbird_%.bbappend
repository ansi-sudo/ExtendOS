FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://extendos-hid.cfg"
